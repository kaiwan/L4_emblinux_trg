PACKAGECONFIG:append = " networkd resolved"

